# Keil uVision project project.uvprojx, settings and files
target stm32g0b1rc-demo (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32G0B1RCTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20023FFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: stm32g0b1rc-demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G0B1xx,IICSOFT
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../HARDWARE/24CXX;../HARDWARE/IIC;../HARDWARE/KEY;../HARDWARE/LED;../HARDWARE/SPI;../HARDWARE/W25QXX;../SYSTEM/sys;../SYSTEM/usart;../HARDWARE/CST816;../HARDWARE/LCD;../HARDWARE/Delay;..\HARDWARE\FT6236
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group Application/MDK-ARM
    ./: startup_stm32g0b1xx.s
  group Application/User/Core
    ../Core/Src/: lcd_demo.c main.c gpio.c dma.c i2c.c rtc.c spi.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c flash_demo.c eeprom_demo.c
  group Hardware
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/CST816/: CST816.c
    ../HARDWARE/LCD/: lcd.c lcd_init.c
    ../HARDWARE/Delay/: delay.c
    ../HARDWARE/IIC/: iic_hal.c
    ../HARDWARE/FT6236/: ft6236.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
software components: CMSIS:CORE 4.3.0
